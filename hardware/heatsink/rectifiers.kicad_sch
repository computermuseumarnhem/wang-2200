File: hardware/heatsink/rectifiers.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: small update in schematic
Parts:
- D? (x2): value D -> 1N1200A
